# Keil uVision project GD_BOOT_SECURE.uvprojx, settings and files
target GD_BOOT_DEV (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: GD32F407ZG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.5.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD_BOOT_DEV +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\Bin\fromelf.exe --bin --output ..\..\Output\GD_BOOT_DEV\GD_BOOT_DEV.bin ..\..\Output\GD_BOOT_DEV\GD_BOOT_DEV.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F407,BOOT_BUILD_DEV=1,BOOT_TRACE=1,BOOT_OPTION_BYTE_PROTECTION_ENABLE=0
  c include: ..\..\Drivers\CMSIS\GD\GD32F4xx\Include;..\..\Drivers\CMSIS;..\..\Drivers\GD32F4xx_standard_peripheral\Include;..\..\User;..\..\Boot\Inc;..\..\Shared;..\..\ThirdParty\Monocypher
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: gdbootloader.sct
  group Boot
    ../../Boot/Src/: boot_fat32.c boot_main.c boot_port.c boot_sd.c boot_system.c boot_crypto.c boot_secure.c boot_security.c
    ../../ThirdParty/Monocypher/: monocypher.c monocypher-ed25519.c
  group Shared
    ../../Shared/: boot_contract.c
  group Startup
    ../../Drivers/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f407_427.s
  group GD32 SPL
    ../../Drivers/GD32F4xx_standard_peripheral/Source/: gd32f4xx_rcu.c gd32f4xx_gpio.c gd32f4xx_misc.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_spi.c gd32f4xx_usart.c
target GD_BOOT_PROD (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: GD32F407ZG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.5.0
  cpu: as above
  output: GD_BOOT_PROD +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\Bin\fromelf.exe --bin --output ..\..\Output\GD_BOOT_PROD\GD_BOOT_PROD.bin ..\..\Output\GD_BOOT_PROD\GD_BOOT_PROD.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F407,BOOT_BUILD_PROD=1,BOOT_OPTION_BYTE_PROTECTION_ENABLE=1
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: gdboot_prod.sct
