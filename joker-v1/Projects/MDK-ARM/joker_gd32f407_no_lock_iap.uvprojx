# Keil uVision project joker_gd32f407_no_lock_iap.uvprojx, settings and files
target Joker_V1_NO_LOCK_APP_A (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: GD32F407ZG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.5.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: NO_LOCK_IAP_A +hex
  AfterMake: "C:\Keil_v5\ARM\ARMCC\Bin\fromelf.exe" --bin --output ..\..\Output\NO_LOCK_IAP_A\NO_LOCK_IAP_A.bin ..\..\Output\NO_LOCK_IAP_A\NO_LOCK_IAP_A.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F407,BOOT_APP_BASE=0x08020000,MACHINE_LOCK_FEATURE_ENABLE=0
  c include: ..\..\Drivers\CMSIS\GD\GD32F4xx\Include;..\..\Drivers\CMSIS;..\..\Drivers\GD32F4xx_standard_peripheral\Include;..\..\User;..\..\App\Inc;..\..\Service\Inc;..\..\BSP\Inc;..\..\BSP\Src;..\..\Drivers;..\..\Drivers\SYSTEM\delay;..\..\Drivers\SYSTEM\sys;..\..\BootSupport
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: IAP_A.sct
  group System
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
    ../../Drivers/RS485/: rs485.c
    ../../Drivers/MODBUS/: modbus.c
  group BSP
    ../../BSP/Src/: award_lamp.c coin.c eeprom.c eye.c gd32f407_hal.c gd32f407.c gtim.c iic.c interrupt.c jackpot_display.c key.c machine_address.c meter.c motor.c nrf24l01.c pcf8563.c segment.c shake.c solenoid.c spi.c ticket.c wiper_motor.c
  group Service
    ../../Service/Src/: account.c audio_manager.c fault.c game.c gift_algorithm.c gift_light.c jackpot.c lottery.c machine_lock.c machine_network.c payout.c remote_config.c device_identity.c score.c self_test.c setting.c standby.c upgrade.c
  group App
    ../../App/Src/: app_main.c app_watchdog.c
  group User
    ../../User/: main.c gd32f4xx_it.c
  group GD32F4xx_Peripherals
    ../../Drivers/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group CMSIS
    ../../Drivers/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Startup
    ../../Drivers/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f407_427.s
  group Boot handoff
    ../../BootSupport/: boot_contract.c
target Joker_V1_NO_LOCK_APP_B (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: GD32F407ZG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.5.0
  cpu: as above
  output: NO_LOCK_IAP_B +hex
  AfterMake: "C:\Keil_v5\ARM\ARMCC\Bin\fromelf.exe" --bin --output ..\..\Output\NO_LOCK_IAP_B\NO_LOCK_IAP_B.bin ..\..\Output\NO_LOCK_IAP_B\NO_LOCK_IAP_B.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F407,BOOT_APP_BASE=0x08060000,MACHINE_LOCK_FEATURE_ENABLE=0
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8060000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: IAP_B.sct
